# Keil uVision project Project_52352.uvprojx, settings and files
target HT32 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HT32F52352_64LQFP Holtek
  pack: Holtek.HT32_DFP.1.0.28
  cpu: IROM(0x00000000,0x1FE00) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HT32 +hex
  AfterMake: fromelf --bin -o "!L.bin" "!L"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52352
  c include: ..\;..\USBD_Library;..\Library\inc;..\utilities;..\core;..\system;..\LIB_CRE\pwm;..\LIB_CRE\delay
  asm define: USE_HT32_CHIP=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group User
    ../: main.c ht32f5xxxx_01_it.c
  group Config
    ../: ht32_board_config.h ht32f5xxxx_conf.h ht32f5xxxx_01_usbdconf.h _ht32_project_source.h
    ./: ht32_op.s HT32F5xxxx_01_DebugSupport.ini
  group CMSIS
    ../: system_ht32f5xxxx_01.c
  group MDK-ARM
    ./: startup_ht32f5xxxx_01.s
  group USBD_Library
    ../USBD_Library/: ht32_usbd_core.c
  group Library
    ../Library/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c
  group Retarget
    ../Library/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../utilities/: ht32_board.c
    ../utilities/common/: ebi_lcd.c i2c_eeprom.c spi_flash.c
  group Doc
    ../: readme.txt
  group pwm
    ../LIB_CRE/pwm/: pwm.c
  group delay
    ../LIB_CRE/delay/: delay.c
